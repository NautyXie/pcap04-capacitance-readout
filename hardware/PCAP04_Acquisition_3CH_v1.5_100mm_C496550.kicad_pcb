# Repository NautyXie/pcap04-capacitance-readout

File README.md:

# PCAP04 3-Channel Capacitance Readout Board

Open-hardware capacitance-to-digital acquisition board built around the
[ScioSense PCAP04](https://www.sciosense.com/pcap04-capacitance-to-digital-converter/)
CDC and an STM32G0B1. Three floating channel pairs or six grounded electrodes,
brought out on SMA edge connectors, with a single USB-C cable for power,
console and firmware update.

Everything here has been built and measured on real hardware — the numbers in
this README are measurements from an assembled v1.5 board, not datasheet
copy.

---

## What it does

| | |
|---|---|
| Channels | 3 floating pairs (PC0/PC1, PC2/PC3, PC4/PC5) **or** 6 grounded electrodes |
| Range | ~385 pF to **1285 pF** full scale, depending on the on-chip reference setting |
| Resolution | sub-aF LSB; **noise floor 4–13 fF** rms depending on averaging and rate |
| Sample rate | 12.8 Hz default, up to **116 Hz** measured |
| Interface | USB-C CDC console (also UART on a header, in parallel) |
| Firmware update | USB DFU — no debug probe needed |
| Board | 100 × 100 mm, 4-layer, SMA edge connectors (C496550) |

Mode switching between floating and grounded takes ~30 ms at runtime; it does
not require re-uploading anything.

## Repository layout

```
hardware/       KiCad 7 project, custom symbols/footprints, 3D models
  manufacturing/  gerbers, drill, IPC netlist
    assembly/       BOM and placement positions
    jlcpcb_pcba/    ready-to-upload JLCPCB assembly packages (BOM + CPL)
firmware/       bare-metal STM32G0B1 firmware (no vendor HAL)
  prebuilt/       pcap04_diag.bin, ready to flash
host/           Python library, CLI and GUI
  characterisation/  the sweeps that produced the numbers in docs/measurements.md
docs/           schematic PDF, design verification report, usage guide,
                measured results
```

## Quick start

### 1. Get a board

`hardware/manufacturing/` contains gerbers, drill files and assembly data ready
to upload. The board is 100 × 100 mm 4-layer; the design rules file is
`hardware/*.kicad_dru`.

For a bare board, upload `PCAP04_v1.5_100mm_C496550_JLCPCB_BARE_BOARD_UPLOAD.zip`.
For an assembled one, use a package under `manufacturing/jlcpcb_pcba/` — but
note that **the PCAP04 itself (LCSC C2829318) is not usually in JLC's assembly
stock and has to be pre-ordered**, and the SMA connectors are hand-soldered.
See [hardware/README.md](hardware/README.md).

### 2. Flash the firmware

No debug probe required — the STM32's ROM bootloader speaks USB DFU, and the
flasher here is pure Python (pyusb, no `dfu-util`):

```bash
cd host
pip3 install -r requirements.txt
python3 pcapdfu.py write ../firmware/prebuilt/pcap04_diag.bin
python3 pcapdfu.py run
```

> A **factory-blank** STM32G0 enters DFU on its own. After the first flash it
> needs one physical unplug/replug of USB-C before it will run your firmware:
> `FLASH_ACR.EMPTY` is only re-evaluated at a power-on reset (RM0444 §2.5.4).
> After that, `python3 pcap.py console dfu` puts it back into DFU on demand.

To build from source you need `arm-none-eabi-gcc`:

```bash
cd firmware && make
```

### 3. Take a measurement

```bash
cd host
python3 pcap.py power on          # U5 load switch -> +3V3P
python3 pcap.py -m f read         # floating, 3 pairs
python3 pcap.py -m g read         # grounded, 6 electrodes
python3 pcap.py stream            # continuous, at the chip's own rate
python3 pcap.py log run.csv -t 60 # 60 s to CSV with running statistics
python3 pcap_gui.py               # graphical strip chart
```

`pcap_gui.py --sim` runs the whole GUI against a built-in simulator, so you can
try the interface before you have a board.

### 4. Calibrate

The chip reports a **ratio** `C / Cref`, so absolute picofarads need one known
capacitor:

```bash
python3 pcap.py calib 100 -c 2    # 100 pF fitted on channel 2
```

Result is stored and loaded automatically from then on.

---

## Things worth knowing before you build one

These cost real debugging time. All measured on the v1.5 board.

**Do not compute Cref from the datasheet formula.** The datasheet gives
`Cref ≈ 0.959·N + 3.23 pF`. This part measures `≈ 0.975·N + 9.91 pF` — the slope
is right to 1.7 % but there is ~7 pF of extra fixed parasitic, and the step
width varies 0.6–1.2 pF between codes (±4 % residual against an affine model).
Calibrate at the code you actually use.

**`DISCHARGE_TIME = 0` breaks real sensors.** The ScioSense reference config
ships with zero discharge time. That is fine for a C0G part on a short trace,
but any sensor with series resistance or a lossy dielectric cannot discharge in
zero time: the port reports `C_PortError` and the reading pins at full scale,
which looks exactly like a dead channel. This firmware defaults to 8. See
[docs/measurements.md](docs/measurements.md).

**`C_AVRG` must stay ≤ 256.** At 512 and above the reading goes ~19.5 % low
(2.4911 → 2.0042 on a 100 pF part). 256 and 257 are both clean, so it is not a
low-byte-zero effect — most likely accumulator saturation with large
capacitances. Firmware and host both clamp.

**A sensor referenced to ground is not a floating sensor.** A level probe
measuring against a tank wall is single-ended. In floating mode the chip
measures the *differential* capacitance between the two ports, and external
compensation deliberately removes each node's capacitance to ground — which is
exactly the signal. The same probe read 0.13 pF floating and 364 pF grounded,
with 36 ppm noise instead of 3800 ppm.

**Config writes need INIT + CDC_START.** Writing a config register alone leaves
the running conversion on the old setting. The first conversion after a restart
is usually garbage (often `0xFFFFFFFF`). The host library handles both.

**The PCAP04's firmware lives in volatile SRAM.** Its NVRAM ships blank, so the
548-byte DSP firmware is uploaded at every power-up. Any reset — a rail cycle or
its own watchdog — zeroes the config registers but **leaves the result
registers holding the previous conversion**, so a dead chip can hand back
plausible-looking stale data. The firmware verifies `RUNBIT` rather than
trusting a cached flag, and the host raises rather than returning stale values.

**Not populated on v1.5:** `PCAUX` (the guard driver output) and the
`PT0REF`/`PT1`/`PTOUT` resistance pins are unrouted, so the integrated guard
driver and external Pt temperature measurement cannot be used on this revision.
`RES6`/`RES7` still return numbers but are only useful as drift indicators.
Route these out if you respin.

---

## Documentation

- [docs/schematic.pdf](docs/schematic.pdf) — rendered schematic, no KiCad needed
- [docs/measurements.md](docs/measurements.md) — every measured figure, and how it was obtained
- [docs/usage.zh.md](docs/usage.zh.md) — full usage guide (Chinese)
- [docs/design-verification-report.pdf](docs/design-verification-report.pdf) — schematic and layout review against the datasheets

## Datasheets

Not redistributed here — they are the vendors' copyrighted documents. Download
from the source:

- PCAP04 — ScioSense
- STM32G0B1 datasheet and RM0444 reference manual — STMicroelectronics
- AN2606 (ROM bootloader) — STMicroelectronics
- TPS22918 load switch, TPS7A20 / TLV755P LDOs, SN74LV125A buffer — Texas Instruments
- USBLC6-2 ESD protection — STMicroelectronics

## Licensing

| Part | Licence |
|---|---|
| `hardware/` | [CERN-OHL-P-2.0](LICENSES/CERN-OHL-P-2.0.txt) |
| `firmware/`, `host/` | [MIT](LICENSES/MIT.txt) |
| `docs/` | [CC-BY-4.0](LICENSES/CC-BY-4.0.txt) |

### Third-party code

`firmware/pcap04_stdfw.h` contains the PCAP04 standard DSP firmware (548 bytes)
and its default configuration (52 bytes), extracted from the
[ScioSense PCAP04 sample code](https://github.com/sciosense/pcap04-sample-code),
which is MIT licensed, **Copyright © 2023 ScioSense**. That copyright notice is
reproduced in the header file. Everything else in `firmware/` is original.

## Contributing

Issues and pull requests welcome. If you build one, a note about what you
measured would be genuinely useful — especially Cref calibration on a different
chip, since the ~7 pF intercept offset documented above is a single-part result
and may or may not be typical.

## Disclaimer

This is a research instrument, published as-is with no warranty. It has been
verified on one assembled board by one person. Check it against your own
requirements before relying on it for anything that matters.

## KiCad design hardware/PCAP04_Acquisition_3CH_v1.5_100mm_C496550.kicad_pcb

File hardware/README.md:

# Hardware

KiCad 7 project for the PCAP04 3-channel capacitance readout board.
100 × 100 mm, 4 layers, SMA edge connectors.

Licence: **CERN-OHL-P-2.0** (permissive). See `../LICENSES/CERN-OHL-P-2.0.txt`.

## Files

```
PCAP04_Acquisition_3CH_v1.5_100mm_C496550.kicad_pro   project
                                          .kicad_sch   root sheet
                                          .kicad_pcb   layout
                                          .kicad_dru   design rules
MCU_CONTROL.kicad_sch      STM32G0B1, SWD, USB, console header
USB_POWER.kicad_sch        USB-C input, protection, rails, U5 load switch
PCAP04_Acquisition.lib     custom symbols
PCAP04_Custom.pretty/      custom footprints
sym-lib-table              symbol library table
fp-lib-table               footprint library table
3dmodels/                  3D models for the custom parts
manufacturing/
  gerber/  drill/            bare-board fabrication
  *_JLCPCB_BARE_BOARD_UPLOAD.zip   the same, zipped for upload
  *_IPC-D-356.net            netlist for electrical test
  assembly/                  KiCad BOM (all / fitted) and placement positions
  jlcpcb_pcba/               ready-to-upload JLCPCB assembly packages
    smt_only/                  49 SMT placements, no through-hole
    j11_fitted/                the same plus the J11 power-select header
```

A rendered schematic is at `../docs/schematic.pdf`, and board renders are in
`../docs/images/`, so you can read the design without installing KiCad.

## Getting one made

`manufacturing/` is ready to upload as-is. It was produced for and verified at
JLCPCB, but the gerbers are standard.

- 4 layers, 1.6 mm, HASL or ENIG both fine
- the SMA edge connectors are C496550 (LCSC part number)

For **bare boards**, upload `manufacturing/PCAP04_v1.5_100mm_C496550_JLCPCB_BARE_BOARD_UPLOAD.zip`
and nothing else.

For **assembled boards**, pick one of the two packages under
`manufacturing/jlcpcb_pcba/` and follow the README inside it — each lists the
exact BOM and CPL files to upload and what is deliberately left unfitted. Two
things there are worth reading before you pay:

- **U1 (PCAP04-AQFM-24, LCSC C2829318) is not normally in JLC's assembly
  stock.** It has to be pre-ordered into My Parts Lib. No substitution is
  acceptable.
- **The SMA connectors J2–J7 are not assembled.** They are edge-mount parts;
  solder them by hand. Same for the headers, except J11 in the `j11_fitted`
  package.

`assembly/` holds the plain KiCad exports (BOM and placement positions) if you
want to feed a different assembler or hand-build.

## Layer stack and why it matters here

| Layer | Use |
|---|---|
| L1 F.Cu | components, sense lines |
| L2 In1.Cu | ground plane |
| L3 In2.Cu | power and signal |
| L4 B.Cu | chassis pour |

The sense traces to the SMA connectors want a continuous ground plane directly
underneath. Measured trace capacitance follows

```
C = 4.18 pF + 0.158 pF/mm
```

for five of the six electrodes, within ±3 %. **PC4 is 20 % off** because it is
routed on L4 under the chassis pour rather than over the ground plane. That was
flagged in the design review before assembly and then confirmed by measurement
— see `../docs/measurements.md` §3. Fix it if you respin.

## Known limitations of v1.5

**`PCAUX` is not routed.** That pin is the PCAP04's integrated guard driver
output. Without it, guarding (`C_G_EN`) cannot be used, which matters if you
want long cables to remote electrodes.

**`PT0REF` / `PT1` / `PTOUT` are not routed.** The resistance-to-digital
converter therefore has no external reference resistor, so external Pt
temperature measurement is unavailable. `RES6`/`RES7` still return numbers, but
treat them only as drift indicators.

**RPS1 was assembled as 33 kΩ where the BOM says 330 kΩ.** This is an assembly
deviation on the built board, not a design error — it changes the +3V3P sense
divider to 133/100. The firmware compensates (`board.h`, `RAIL_DIV_NUM`), and
the `div` console command overrides it. Check what is actually fitted on yours.

If you respin, routing `PCAUX` and the PT pins out to test points would be the
two highest-value changes.

Parts:
C1, C2: 100n; C_0402_1005Metric
C3: 10u; C_0805_2012Metric
C4: 4.7u; C_0603_1608Metric
C5: 100n_DNP; C_0402_1005Metric; not fitted
CCH0: 1n_DNP; C_0603_1608Metric; not fitted
CTEST1: 100pF_C0G_0.1%_DNP; C_0603_1608Metric; not fitted
ESD0, ESD1, ESD2, ESD3, ESD4, ESD5: DNP; D_SOD-882; not fitted
J2, J3, J4, J5, J6, J7: BWSMA-KE-P001 / C496550; SMA_Bat_Wireless_BWSMA-KE-P001_EdgeMount_1.6mm-PCB
RCH0: 0R_FITTED; R_0603_1608Metric
RCH1: 1M_DNP; R_0603_1608Metric; not fitted
RCS_PU1: 100k; R_0402_1005Metric
RPC0, RPC1, RPC2, RPC3, RPC4, RPC5: 0R; R_0402_1005Metric
U1: PCAP04-AQFM-24_V2; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+3V3P: C1.1, C2.1, C3.1, RCS_PU1.2, U1.4 (VDD33A), U1.14 (VDD33B); also elsewhere on the board
/VDD18_LOCAL: C4.1, C5.1, U1.3 (VDD18)
CHASSIS: CCH0.1, ESD0.2 (A), ESD1.2 (A), ESD2.2 (A), ESD3.2 (A), ESD4.2 (A), ESD5.2 (A), J2.2 (SHIELD), J3.2 (SHIELD), J4.2 (SHIELD), J5.2 (SHIELD), J6.2 (SHIELD), J7.2 (SHIELD), RCH0.1, RCH1.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CCH0.2, RCH0.2, RCH1.2, U1.2 (GND1), U1.8 (GND2), U1.13 (IIC_EN), U1.25 (EP_GND); also elsewhere on the board
unnamed: ESD0.1 (K), RPC0.2, U1.22 (PC0)
unnamed: ESD1.1 (K), RPC1.2, U1.23 (PC1)
unnamed: ESD2.1 (K), RPC2.2, U1.24 (PC2)
unnamed: ESD3.1 (K), RPC3.2, U1.1 (PC3)
unnamed: CTEST1.1, ESD4.1 (K), RPC4.2, U1.20 (PC4)
unnamed: CTEST1.2, ESD5.1 (K), RPC5.2, U1.21 (PC5)
unnamed: J2.1 (CENTER), RPC0.1
unnamed: J3.1 (CENTER), RPC1.1
unnamed: J4.1 (CENTER), RPC2.1
unnamed: J5.1 (CENTER), RPC3.1
unnamed: J6.1 (CENTER), RPC4.1
unnamed: J7.1 (CENTER), RPC5.1
PCAP_CS_N: RCS_PU1.1, U1.9 (SSN); also elsewhere on the board
PCAP_IRQ: U1.11 (PG5_IRQ); also elsewhere on the board
PCAP_MISO: U1.10 (MISO); also elsewhere on the board
PCAP_MOSI: U1.15 (MOSI); also elsewhere on the board
PCAP_SCK: U1.16 (SCK); also elsewhere on the board

Notes on the sheet:
LEVEL2 OUTER / PC3
LEVEL3 OUTER / PC5
LEVEL2 INNER / PC2
LEVEL1 OUTER / PC1
LEVEL3 INNER / PC4
RCH0=0R 首装；RCH1/CCH0 均 DNP，不得形成第二个机壳连接点。
LEVEL1 INNER / PC0
J2/J3、J4/J5、J6/J7 分别为 LEVEL1/2/3 浮地电极对；三路均为正式测量通道，无 50 ohm 终端。
全局网络连接到 P2 / P3
CTEST1 默认 DNP；仅在断开 J6/J7 外部探头后装入作 100 pF 自检。
VDD18_LOCAL 是 U1 内部 1.8 V 稳压输出，仅接 C4/C5；严禁连接 +3V3P。
P1 三通道液位传感器输入与 PCAP04
机壳单点连接
每只 SMA 中心接一个电极；全部外壳接 CHASSIS。罐体不接 PC0-PC5；ESD0-ESD5 首板 DNP。

Parts:
C6, C8, C9: 100n; C_0402_1005Metric
C7: 10u; C_0805_2012Metric
C10: 4.7u; C_0603_1608Metric
C15: 10n_C0G; C_0402_1005Metric
CCT1: 1n; C_0402_1005Metric
CNRST1: 100n; C_0402_1005Metric
J9: SWD; PinHeader_1x05_P2.54mm_Vertical
J10: UART_HOST; PinHeader_1x06_P2.54mm_Vertical
RCS1: 33R; R_0402_1005Metric
RENPD1: 100k; R_0402_1005Metric
RIRQ1: 1k; R_0402_1005Metric
RIRQPD1: 10k; R_0402_1005Metric
RMOSI1: 33R; R_0402_1005Metric
RNRST1: 10k; R_0402_1005Metric
ROEPU1: 100k; R_0402_1005Metric
RPS1: 330k; R_0402_1005Metric
RPS2: 100k; R_0402_1005Metric
RQOD1: 470R; R_0402_1005Metric
RSCK1: 33R; R_0402_1005Metric
SW1: RESET; SW_SPST_PTS810
U2: STM32G0B1CBT6; LQFP-48_7x7mm_P0.5mm
U5: TPS22918DBVR; SOT-23-6
U6: SN74LV125APWR; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3V3A: U5.1 (VIN); also elsewhere on the board
+3V3D: C6.1, C8.1, C9.1, C10.1, J9.1, J10.1, RNRST1.1, ROEPU1.1, U2.4 (VBAT), U2.5 (VREF+), U2.6 (VDD/VDDA), U6.14 (VCC); also elsewhere on the board
+3V3P: C7.1, RPS1.1, RQOD1.2, U5.6 (VOUT); also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C15.2, CCT1.2, CNRST1.2, J9.5, J10.6, RENPD1.2, RIRQPD1.2, RPS2.2, SW1.2, U2.7 (VSS/VSSA), U5.2 (GND), U6.7 (GND); also elsewhere on the board
HOST_READY: J10.4, U2.23 (PB11-HOST_READY)
MEAS_BUSY: J10.5, U2.24 (PB12-MEAS_BUSY)
NRST: CNRST1.1, J9.4, RNRST1.2, SW1.1, U2.10 (PF2-NRST)
unnamed: U2.16 (PA5-SPI1_SCK), U6.2 (A1)
unnamed: U2.17 (PA6-SPI1_MISO), U6.11 (Y4)
unnamed: U2.18 (PA7-SPI1_MOSI), U6.5 (A2)
unnamed: U2.19 (PB0-PCAP_CS), U6.9 (A3)
unnamed: RIRQ1.2, U2.20 (PB1-PCAP_IRQ)
unnamed: CCT1.1, U5.4 (CT)
unnamed: RQOD1.1, U5.5 (QOD)
unnamed: RSCK1.2, U6.3 (Y1)
unnamed: RMOSI1.2, U6.6 (Y2)
unnamed: RCS1.2, U6.8 (Y3)
PCAP_CS_N: RCS1.1; also elsewhere on the board
PCAP_IRQ: RIRQ1.1, RIRQPD1.1; also elsewhere on the board
PCAP_MISO: U6.12 (A4); also elsewhere on the board
PCAP_MOSI: RMOSI1.1; also elsewhere on the board
PCAP_PWR_EN: RENPD1.1, U2.21 (PB2-PCAP_PWR_EN), U5.3 (ON)
PCAP_PWR_SENSE: C15.1, RPS1.2, RPS2.1, U2.11 (PA0)
PCAP_SCK: RSCK1.1; also elsewhere on the board
PCAP_SPI_OE_N: ROEPU1.2, U2.22 (PB10-SPI_OE_N), U6.1 (1OE), U6.4 (2OE), U6.10 (3OE), U6.13 (4OE)
SWCLK_BOOT0: J9.3, U2.36 (PA14-SWCLK-BOOT0)
SWDIO: J9.2, U2.35 (PA13-SWDIO)
UART_RX: J10.3, U2.14 (PA3-UART_RX)
UART_TX: J10.2, U2.13 (PA2-UART_TX)
USB_DM: U2.33 (PA11-USB_DM); also elsewhere on the board
USB_DP: U2.34 (PA12-USB_DP); also elsewhere on the board

Notes on the sheet:
上电：SPI 保持高阻 -> 开 U5 -> 稳定 -> 使能 SPI -> 写入并回读配置。
1 停止转换 -> 2 SPI 高阻 -> 3 关闭 U5
PA14 同时为 SWCLK/BOOT0。BOOT 模式通过选项字节管理；本板不在 PA14 上放置影响 SWD 的电容。
GPIO/PIN：PB2=PCAP_PWR_EN，PB10=PCAP_SPI_OE_N，PA0=PCAP_PWR_SENSE；USB CDC 为主链路。
安全时序（固件必须执行）
P2 STM32G0B1 控制、SPI 缓冲/三态保护与 PCAP04 主动开关
4 PA0 实测 +3V3P < 0.05 V -> 5 才允许重新上电

Parts:
C11, C13: 1u; C_0603_1608Metric
C12: 4.7u; C_0603_1608Metric
C14: 10u; C_0805_2012Metric
D1: SMF5.0A; D_SOD-123F
F1: 500mA_PTC; Fuse_1206_3216Metric
FB1: 600R@100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB-C_USB2_DEVICE; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J8: EXT_5V_LOW_NOISE; PinHeader_1x02_P2.54mm_Vertical
J11: 5V_SOURCE_SELECT; PinHeader_1x03_P2.54mm_Vertical
RCC1, RCC2: 5.1k_1%; R_0402_1005Metric
U3: TLV75533PDBVR; SOT-23-5
U4: TPS7A2033PDBVR; SOT-23-5
U7: USBLC6-2SC6; SOT-23-6

Connections:
+3V3A: C14.1, U4.5 (OUT); also elsewhere on the board
+3V3D: C12.1, U3.5 (OUT); also elsewhere on the board
+5V_AIN: C13.1, FB1.2, U4.1 (IN), U4.3 (EN)
+5V_EXT: J8.1, J11.3
+5V_IN: C11.1, FB1.1, J11.2, U3.1 (IN), U3.3 (EN)
+5V_USB: D1.1 (K), F1.2, J11.1, U7.5 (VBUS)
CHASSIS: J1.SH (SHIELD); also elsewhere on the board
GND: C11.2, C12.2, C13.2, C14.2, D1.2 (A), J1.A1 (GND_A1), J1.A12 (GND_A12), J1.B1 (GND_B1), J1.B12 (GND_B12), J8.2, RCC1.2, RCC2.2, U3.2 (GND), U4.2 (GND), U7.2 (GND); also elsewhere on the board
unnamed: J1.A5 (CC1_A5), RCC1.1
unnamed: J1.B5 (CC2_B5), RCC2.1
unnamed: J1.A6 (D+_A6), J1.B6 (D+_B6), U7.1 (D+_IN)
unnamed: J1.A7 (D-_A7), J1.B7 (D-_B7), U7.3 (D-_IN)
unnamed: F1.1, J1.A4 (VBUS_A4), J1.A9 (VBUS_A9), J1.B4 (VBUS_B4), J1.B9 (VBUS_B9)
USB_DM: U7.4 (D-_OUT); also elsewhere on the board
USB_DP: U7.6 (D+_OUT); also elsewhere on the board

Notes on the sheet:
J11: 1-2=USB；2-3=外部低噪声 5 V。
模拟电源 +3V3A（经 FB1 与低噪声 LDO）
USB DP/DM 90 ohm 差分、等长并远离 SMA/PCAP；外部 5 V 输入仅用于台架 A/B 噪声测试。
ERC 电源源标记（不表示负载路径）
布局要求：USB/TVS/数字 LDO 靠 J1；U4/FB1 靠 U5 与 PCAP 区域；L2 保持连续 GND，不切割地平面。
数字电源 +3V3D
P3 USB-C 数据与低噪声电源
数据路径和供电路径分开绘制；J11 跳帽只能选择 USB 或外部 5 V，禁止并联。

Board: 4 copper layers, 100.0 x 100.0 mm, 69 parts (0 on the bottom side), 54 nets.

File hardware/manufacturing/assembly/PCAP04_v1.5_100mm_C496550_BOM_all.csv:

"Refs","Value","Footprint","Datasheet","Qty","DNP"
"C1,C2,C6,C8,C9,CNRST1","100n","Capacitor_SMD:C_0402_1005Metric","","6",""
"C3,C7,C14","10u","Capacitor_SMD:C_0805_2012Metric","","3",""
"C4,C10,C12","4.7u","Capacitor_SMD:C_0603_1608Metric","","3",""
"C5","100n_DNP","Capacitor_SMD:C_0402_1005Metric","","1","DNP"
"C11,C13","1u","Capacitor_SMD:C_0603_1608Metric","","2",""
"C15","10n_C0G","Capacitor_SMD:C_0402_1005Metric","","1",""
"CCH0","1n_DNP","Capacitor_SMD:C_0603_1608Metric","","1","DNP"
"CCT1","1n","Capacitor_SMD:C_0402_1005Metric","","1",""
"CTEST1","100pF_C0G_0.1%_DNP","Capacitor_SMD:C_0603_1608Metric","","1","DNP"
"D1","SMF5.0A","Diode_SMD:D_SOD-123F","","1",""
"ESD0-ESD5","DNP","Diode_SMD:D_SOD-882","","6","DNP"
"F1","500mA_PTC","Fuse:Fuse_1206_3216Metric","","1",""
"FB1","600R@100MHz","Inductor_SMD:L_0603_1608Metric_Pad1.05x0.95mm_HandSolder","","1",""
"J1","USB-C_USB2_DEVICE","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","","1",""
"J2-J7","BWSMA-KE-P001 / C496550","PCAP04_Custom:SMA_Bat_Wireless_BWSMA-KE-P001_EdgeMount_1.6mm-PCB","","6",""
"J8","EXT_5V_LOW_NOISE","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","","1",""
"J9","SWD","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","","1",""
"J10","UART_HOST","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical","","1",""
"J11","5V_SOURCE_SELECT","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","","1",""
"RCC1,RCC2","5.1k_1%","Resistor_SMD:R_0402_1005Metric","","2",""
"RCH0","0R_FITTED","Resistor_SMD:R_0603_1608Metric","","1",""
"RCH1","1M_DNP","Resistor_SMD:R_0603_1608Metric","","1","DNP"
"RCS1,RMOSI1,RSCK1","33R","Resistor_SMD:R_0402_1005Metric","","3",""
"RCS_PU1,RENPD1,ROEPU1,RPS2","100k","Resistor_SMD:R_0402_1005Metric","","4",""
"RIRQ1","1k","Resistor_SMD:R_0402_1005Metric","","1",""
"RIRQPD1,RNRST1","10k","Resistor_SMD:R_0402_1005Metric","","2",""
"RPC0-RPC5","0R","Resistor_SMD:R_0402_1005Metric","","6",""
"RPS1","330k","Resistor_SMD:R_0402_1005Metric","","1",""
"RQOD1","470R","Resistor_SMD:R_0402_1005Metric","","1",""
"SW1","RESET","Button_Switch_SMD:SW_SPST_PTS810","","1",""
"U1","PCAP04-AQFM-24_V2","Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm","","1",""
"U2","STM32G0B1CBT6","Package_QFP:LQFP-48_7x7mm_P0.5mm","","1",""
"U3","TLV75533PDBVR","Package_TO_SOT_SMD:SOT-23-5","","1",""
"U4","TPS7A2033PDBVR","Package_TO_SOT_SMD:SOT-23-5","","1",""
"U5","TPS22918DBVR","Package_TO_SOT_SMD:SOT-23-6","https://www.ti.com/lit/ds/symlink/tps22918.pdf","1",""
"U6","SN74LV125APWR","Package_SO:TSSOP-14_4.4x5mm_P0.65mm","","1",""
"U7","USBLC6-2SC6","Package_TO_SOT_SMD:SOT-23-6","","1",""

## Code that names these connections

File firmware/main.c (part):

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 *
 * Console is available over TWO transports simultaneously:
 *   1. a RAM mailbox read/written by the host over SWD  (no extra wires)
 *   2. USART2 on PA2/PA3 -> header J10               (115200 8N1)
 *
 * The firmware never powers the PCAP04 by itself; every rail change follows
 * the sequence written on schematic sheet P2.
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    pin_set(GPIOB, PIN_SPI_OE_N);            /* 1 = SPI buffer tri-stated    */
    pin_mode(GPIOB, PIN_SPI_OE_N, GPIO_MODE_OUT);

    pin_clr(GPIOB, PIN_PCAP_PWR_EN);         /* 0 = +3V3P off                */
    pin_mode(GPIOB, PIN_PCAP_PWR_EN, GPIO_MODE_OUT);

    pin_set(GPIOB, PIN_PCAP_CS);             /* SSN idle high                */
    pin_mode(GPIOB, PIN_PCAP_CS, GPIO_MODE_OUT);
    pin_speed_high(GPIOB, PIN_PCAP_CS);

    pin_pull(GPIOB, PIN_PCAP_IRQ, GPIO_PULL_UP);   /* INTN is active low     */
    pin_mode(GPIOB, PIN_PCAP_IRQ, GPIO_MODE_IN);

    pin_clr(GPIOB, PIN_HOST_READY); pin_mode(GPIOB, PIN_HOST_READY, GPIO_MODE_OUT);
    pin_clr(GPIOB, PIN_MEAS_BUSY);  pin_mode(GPIOB, PIN_MEAS_BUSY,  GPIO_MODE_OUT);

    pin_mode(GPIOA, PIN_PWR_SENSE, GPIO_MODE_ANALOG);
}

/* =====================================================================
 * USART2 (PA2/PA3, AF1) -> J10
 * ===================================================================== */
static void uart_init(void)
{
    RCC_APBENR1 |= RCC_APBENR1_USART2EN;
    pin_af(GPIOA, PIN_UART_TX, AF_USART2); pin_mode(GPIOA, PIN_UART_TX, GPIO_MODE_AF);
    pin_af(GPIOA, PIN_UART_RX, AF_USART2); pin_mode(GPIOA, PIN_UART_RX, GPIO_MODE_AF);
    pin_pull(GPIOA, PIN_UART_RX, GPIO_PULL_UP);
    USART2->CR1 = 0;
    USART2->BRR = (PCLK_HZ + UART_BAUD / 2u) / UART_BAUD;
    USART2->CR1 = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
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    if (raw == 0 || cal == 0 || cal == 0xFFFF) { return 0; }
    return (uint32_t)VREFINT_CAL_VREF * cal / raw;
}
/* V(+3V3P) = V(PA0) * (RPS1+RPS2)/RPS2.  See the note in board.h: this board
 * has 33k fitted for RPS1, so the ratio is 1.33 and not the 4.30 of the BOM. */
static uint32_t g_div_num = RAIL_DIV_NUM;
static uint32_t g_div_den = RAIL_DIV_DEN;
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static uint32_t rail_mv(void)
{
    uint32_t vdda = vdda_mv();
    uint32_t raw, pa0;
    if (vdda == 0) { return 0; }
    raw = adc_read(PIN_PWR_SENSE);
    pa0 = vdda * raw / 4095u;
    return pa0 * g_div_num / g_div_den;
}

/* =====================================================================
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static void safe_shutdown(void)
{
    pin_set(GPIOB, PIN_SPI_OE_N);          /* SPI bus tri-stated             */
    pin_clr(GPIOB, PIN_PCAP_PWR_EN);       /* +3V3P off                      */
    pin_set(GPIOB, PIN_PCAP_CS);
    g_rail_on = 0; g_bus_on = 0; g_loaded = 0u;
}
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{
    uint32_t t0, mv = 0; int i;
    bus_disable();                                  /* step 1: SPI Hi-Z      */
    pin_set(GPIOB, PIN_PCAP_PWR_EN);                /* step 2: U5 ON         */
    t0 = now_ms();
    for (i = 0; i < 400; i++) {
        mv = rail_mv();
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    }
    if (mv < RAIL_ON_MV) {
        cprintf("  FAIL +3V3P only reached "); print_mv(mv); cputs(" after 400 ms\n");
        pin_clr(GPIOB, PIN_PCAP_PWR_EN);
        g_rail_on = 0;
        return -1;
    }
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{
    uint32_t t0, mv = 0; int i;
    bus_disable();                                  /* steps 1-2             */
    pin_clr(GPIOB, PIN_PCAP_PWR_EN);                /* step 3: U5 OFF        */
    t0 = now_ms();
    for (i = 0; i < 1000; i++) {
        mv = rail_mv();
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}
static void cmd_pins(void)
{
    cprintf("PB2  PCAP_PWR_EN  = %u  (1 = +3V3P enabled)\n", pin_get(GPIOB, PIN_PCAP_PWR_EN));
    cprintf("PB10 SPI_OE_N     = %u  (1 = buffer tri-stated)\n", pin_get(GPIOB, PIN_SPI_OE_N));
    cprintf("PB0  PCAP_CS      = %u  (1 = deselected)\n", pin_get(GPIOB, PIN_PCAP_CS));
    cprintf("PB1  PCAP_IRQ     = %u  (INTN active LOW)\n", pin_get(GPIOB, PIN_PCAP_IRQ));
    cprintf("PB11 HOST_READY   = %u\n", pin_get(GPIOB, PIN_HOST_READY));
    cprintf("PB12 MEAS_BUSY    = %u\n", pin_get(GPIOB, PIN_MEAS_BUSY));
}
static void cmd_adc(void)
{
    uint32_t vdda = vdda_mv();
    uint16_t raw  = adc_read(PIN_PWR_SENSE);
    cputs("VDDA (VREFINT)  = "); print_mv(vdda); cputc('\n');
    cprintf("PA0 raw         = %u / 4095\n", (uint32_t)raw);
    cputs("PA0 voltage     = "); print_mv(vdda ? vdda * raw / 4095u : 0u); cputc('\n');
    cprintf("divider         = %u/%u\n", g_div_num, g_div_den);
    cputs("+3V3P           = "); print_mv(rail_mv()); cputc('\n');
}
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    cprintf("     INFO %s\n", reset_cause(g_csr_at_boot));

    cprintf("[%u] control pin safe state\n", ++step);
    if (pin_get(GPIOB, PIN_SPI_OE_N) == 1u && pin_get(GPIOB, PIN_PCAP_PWR_EN) == 0u) {
        cputs("     PASS SPI buffer tri-stated, +3V3P disabled\n");
    } else { cputs("     FAIL control pins not in safe state\n"); ok = 0; }

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        if (rb == 0xA5u) { cputs("PASS\n"); } else { cputs("FAIL\n"); ok = 0; }
    } else { cputs("     SKIP\n"); }

    cprintf("[%u] PCAP_IRQ pin\n", ++step);
    cprintf("     INFO PB1 = %u (INTN is active low; high = idle)\n", pin_get(GPIOB, PIN_PCAP_IRQ));

    cprintf("[%u] power down sequence\n", ++step);
    if (rail_off() != 0) { ok = 0; } else { cputs("     PASS\n"); }
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static uint8_t g_cfg[PCAP04_STD_CFG_LEN];

/* Front-end mode.  The ScioSense default config is a grounded-sensor setup
 * using an EXTERNAL reference at PC0.  This board has neither, so both modes
 * below use the on-chip reference at its largest setting.
 *
 *   floating : three sensor PAIRS, PC0/PC1, PC2/PC3, PC4/PC5, results in
 *              RES0..RES2.  Both compensations on - external compensation
 *              removes the trace-to-ground capacitance and is only legal
 *              when C_FLOATING = 1.
 *   grounded : six single-ended electrodes PC0..PC5 against GND, results in
 *              RES0..RES5.  Internal compensation only; the datasheet says
 *              C_COMP_EXT "must be avoided when C_FLOATING == 0".
 */
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 * the port reports C_PortError, with the result pinned at full scale.  It
 * looks exactly like "the channel is dead".
 *
 * Measured on this board with a level probe on PC2/PC3: DISCHARGE_TIME = 0
 * errors, 2 already clears it, and anything up to 8 keeps the full 12.8 Hz.
 * At 10 and above the conversion no longer fits one trigger period and the
 * rate halves.  8 is the default here: clear margin, no rate cost. */
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{
    /* bit7 C_REF_INT, bit5 C_COMP_EXT, bit4 C_COMP_INT, bit0 C_FLOATING */
    g_cfg[4]  = floating ? 0xB1u : 0x90u;
    g_cfg[6]  = 0x3Fu;                            /* C_PORT_EN = PC0..PC5   */
    g_cfg[17] = (uint8_t)((g_cfg[17] & 0x03u) | (C_REF_SEL_DEF << 2));
    g_cfg[12] = (uint8_t)(DISCHARGE_TIME_DEF & 0xFFu);
    g_cfg[13] = (uint8_t)((g_cfg[13] & ~0x03u) | ((DISCHARGE_TIME_DEF >> 8) & 3u));
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    cputs("  CDC_START (0x8C) - conversions are running\n");
    pcap_cmd(PCAP_OP_CDC_START);
    delay_ms(50);
    cprintf("  PCAP_IRQ (INTN, active low) now reads %u\n", pin_get(GPIOB, PIN_PCAP_IRQ));
    g_loaded = 1u;
    g_mode = (uint8_t)(floating ? MODE_FLOATING : MODE_GROUNDED);
    return 0;
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    {
        uint8_t s0 = pcap_rd_res(0x20u), s1 = pcap_rd_res(0x21u), s2 = pcap_rd_res(0x22u);
        cprintf("  status 0x20..0x22 = %02X %02X %02X   INTN=%u\n",
                (uint32_t)s0, (uint32_t)s1, (uint32_t)s2, pin_get(GPIOB, PIN_PCAP_IRQ));
        if (!(s0 & 0x01u)) {
            g_loaded = 0u;
            cputs("  WARNING: RUNBIT is clear - the PCAP04 has been reset.  Its config\n"
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    { uint32_t i; for (i = 0; i < 6u; i++) { if (s2 & (1u << i)) { cprintf(" PortErr(PC%u)", i); } } }
    if (!(s2 & 0x7Fu)) { cputs(" no port errors"); }
    cputc('\n');
    cprintf("  INTN pin (PB1)  = %u  (active low)\n", pin_get(GPIOB, PIN_PCAP_IRQ));
    cprintf("  +3V3P rail      = %s, measured ", g_rail_on ? "ON" : "OFF");
    print_mv(rail_mv()); cputc('\n');
}
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        uint32_t t0 = now_ms();
        int got = 0;
        while ((now_ms() - t0) < 3000u) {
            if (pin_get(GPIOB, PIN_PCAP_IRQ) == 0u) { got = 1; break; }
            if (host_key()) { aborted = 1; break; }
        }
        if (aborted) { break; }
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    "  help                 this list\n"
    "  info                 MCU id, UID, flash size, clocks, reset cause\n"
    "  pins                 state of every control pin\n"
    "  adc                  VDDA, PA0 raw, computed +3V3P\n"
    "  rail on|off          power sequence for +3V3P (U5)\n"
    "  bus on|off           SPI buffer output enable (U6)\n"
    "  spi <0-7>            SPI prescaler: 0=/2 ... 5=/64 ... 7=/256\n"
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    "  refsel <n>           C_REF_SEL 0..31, on-chip reference capacitor\n"
    "  disch <n>            DISCHARGE_TIME; raise it if a port reports an error\n"
    "  comp <0-3>           bit0 internal, bit1 external compensation\n"
    "  ports <hex>          C_PORT_EN bitmask for PC0..PC5\n"
    "  params               decode the current front-end configuration\n"
    "  usb                  USB CDC link state, resets, dropped bytes\n"
    "  health               decode STATUS_0/1/2, INTN and the rail\n"
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
File firmware/board.h:

/* SPDX-License-Identifier: MIT */
/* board.h - PCAP04_Acquisition_3CH v1.5 (100 mm, C496550) pin map.
 * Derived directly from the v1.5 KiCad netlist; see the design report,
 * Table "Microcontroller pin allocation".
 */
#ifndef BOARD_H
#define BOARD_H
#include "stm32g0b1.h"

#define BOARD_NAME  "PCAP04_Acquisition_3CH v1.5 / 100mm / C496550"
#define FW_NAME     "diag+stdfw+stream+usb"
#define FW_VERSION  "3.3.0"

#define SYSCLK_HZ   64000000u
#define PCLK_HZ     64000000u
#define UART_BAUD   115200u

/* ---- port A ------------------------------------------------------------ */
#define PIN_PWR_SENSE   0    /* PA0  ADC_IN0  <- RPS1/RPS2 divider on +3V3P  */
#define PIN_UART_TX     2    /* PA2  AF1 USART2_TX  -> J10 pin 2             */
#define PIN_UART_RX     3    /* PA3  AF1 USART2_RX  <- J10 pin 3             */
#define PIN_SPI_SCK     5    /* PA5  AF0 SPI1_SCK   -> U6 A1                 */
#define PIN_SPI_MISO    6    /* PA6  AF0 SPI1_MISO  <- U6 Y4                 */
#define PIN_SPI_MOSI    7    /* PA7  AF0 SPI1_MOSI  -> U6 A2                 */
#define AF_USART2       1u
#define AF_SPI1         0u

/* ---- port B ------------------------------------------------------------ */
#define PIN_PCAP_CS     0    /* PB0  -> U6 A3 -> RCS1 -> U1 SSN, active low  */
#define PIN_PCAP_IRQ    1    /* PB1  <- RIRQ1 <- U1 PG5/INTN, active LOW     */
#define PIN_PCAP_PWR_EN 2    /* PB2  -> U5 ON.  HIGH = +3V3P on              */
#define PIN_SPI_OE_N    10   /* PB10 -> U6 1..4OE.  HIGH = bus tri-stated    */
#define PIN_HOST_READY  11   /* PB11 -> J10 pin 4                            */
#define PIN_MEAS_BUSY   12   /* PB12 -> J10 pin 5                            */

/* ---- +3V3P rail monitor ------------------------------------------------ *
 * RPS1 = 330k from +3V3P, RPS2 = 100k to GND, C15 = 10 nF.
 * V(+3V3P) = V(PA0) * (330 + 100) / 100 = V(PA0) * 4.30
 * Source impedance 330k||100k = 76.7 kohm -> longest ADC sample time.       */
/* MEASURED ON THE v1.5 BOARD: RPS1 is fitted as 33k, not the 330k in the BOM.
 * PA0 reads 2.485 V with the rail at 3.30 V  ->  ratio (33+100)/100 = 1.33.
 * The design value would be 430/100.  Override at runtime with 'div n d'.   */
#define RAIL_DIV_NUM    133u
#define RAIL_DIV_DEN    100u
#define RAIL_DIV_NUM_DESIGN 430u
#define RAIL_ON_MV      3000u   /* rail considered up above this             */
#define RAIL_OFF_MV     150u    /* ADC offset x divider ratio sets the floor */

/* ---- PCAP04 serial interface (datasheet SC-001050-DS-6, table 76) ------ *
 * SPI mode 1 (CPOL = 0, CPHA = 1), MSB first.                              */
#define PCAP_OP_WR_CFG   0xA3u   /* 0xA3, 0xC0|addr, data                    */
#define PCAP_OP_RD_CFG   0x23u   /* 0x23, 0xC0|addr, -> data                 */
#define PCAP_OP_RD_RES   0x40u   /* 0x40|addr, -> data                       */
#define PCAP_OP_WR_MEM   0xA0u   /* 0xA0|addr[9:8], addr[7:0], data          */
#define PCAP_OP_RD_MEM   0x20u   /* 0x20|addr[9:8], addr[7:0], -> data       */
#define PCAP_OP_POR      0x88u
#define PCAP_OP_INIT     0x8Au
#define PCAP_OP_CDC_START 0x8Cu
#define PCAP_OP_RDC_START 0x8Eu
#define PCAP_OP_DSP_TRIG  0x8Du
#define PCAP_TESTREAD    0x7Eu   /* == RD_RES addr 62; must return 0x11      */
#define PCAP_SCRATCH_CFG 0x10u   /* FULLCHARGE_TIME: plain data, no side effects */
#define PCAP_SCRATCH_MEM 0x3FFu  /* top of the 1 kB SRAM                     */
#define PCAP_TESTREAD_OK 0x11u
#define PCAP_POWERUP_MS  10u     /* datasheet: operational 4 ms after power  */

#endif /* BOARD_H */
